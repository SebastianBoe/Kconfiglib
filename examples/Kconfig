## examples/Kconfig
```kconfig
choice
	prompt "Boe"
	default FOO

config FOO
	bool "Foo"

config BAR
	bool "Bar"

endchoice
```
